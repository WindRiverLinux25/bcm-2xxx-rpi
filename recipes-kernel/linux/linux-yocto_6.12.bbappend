require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH:rpi = "v6.12/standard/bcm-2xxx-rpi"
